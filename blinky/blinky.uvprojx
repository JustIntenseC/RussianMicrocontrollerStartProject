# Keil uVision project blinky.uvprojx, settings and files
target blinky_K1921VK035 (6190000::V6.19::ARMCLANG)
  device: K1921VK035 Generic
  pack: NIIET.K1921VK035_DFP.2.0.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=3
  c define: RETARGET, SYSCLK_PLL, OSECLK_VAL=16000000
  c include: .\CMSIS\Core\Include;.\CMSIS\Device\Include;.\bsp\NIIET-BB-K1921VK035;..\blinky;.\Retarget
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group startup
    ./CMSIS/Device/Source/: system_K1921VK035.c
    ./CMSIS/Device/Source/ARM/: startup_K1921VK035.s
  group src
    ./: main.c
  group bsp
    ./bsp/NIIET-BB-K1921VK035/: bsp.c bsp.h
  group Retarget
    ./Retarget/: Retarget.c
